# IAR project Lorikeet4_S.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Lorikeet4_S.srec
  ILINK.IlinkOutputFile: Lorikeet4_S.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  ICCSTM8.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: Lorikeet4_S.hex
  group (top)
    ./: at.c at.h flash.c flash.h globals.h gps.h led.h payload.c payload.h typedefs.h uart.c uart.h
    $EW_DIR$/stm8/inc/c/: intrinsics.h
    $EW_DIR$/stm8/inc/: io_macros.h
  group source
    ./: gps.c led.c main.c pins.c
